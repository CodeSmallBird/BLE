# Keil uVision project ShakeCool.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..\..\pro_templates_v11.25;..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\s110;..\Include\sd_common;..\head_file
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Startup Code
    ../Source/templates/arm/: arm_startup_nrf51.s
    ../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../Source/ble/ble_services/: ble_dis.c
    ../user_file/: ble_trans.c
  group Libraries
    ../Source/ble/: ble_error_log.c ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_bondmngr.c ble_debug_assert_handler.c
    ../Source/ble/ble_services/: ble_srv_common.c
    ../Source/app_common/: app_timer.c pstorage.c crc16.c app_button.c app_gpiote.c pstorage_lhat.c app_scheduler.c
    ../Source/sd_common/: softdevice_handler.c
    ../Source/nrf_delay/: nrf_delay.c
    ../Source/nrf_nvmc/: nrf_nvmc.c
    ../Source/simple_uart/: simple_uart.c
  group User
    ../user_file/: ble_service.c ble_exdevice.c
  group PowerCtrl
    ../user_file/power_ctrl/: power_ctrl.c
  group DataTrains
    ../user_file/data_trans/: data_trans.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ShakeCool_V128 +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\s110;..\Include\sd_common;..\head_file;..\Include\boards;..\user_file\power_ctrl;..\user_file\data_trans
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
